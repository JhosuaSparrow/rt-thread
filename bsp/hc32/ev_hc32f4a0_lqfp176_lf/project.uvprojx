# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.6
  cpu: IROM(0x00000000,0x200000) IRAM(0x1FFE0000,0x80000)  IRAM2(0X200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(240000000) ESEL ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, USE_DDL_DRIVER, HC32F4A0, __RTTHREAD__
  c include: ..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\posix\io\poll;..\..\..\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\usb\usbdevice;.;..\libraries\hc32f4a0_ddl\drivers\cmsis\Include;..\libraries\hc32f4a0_ddl\drivers\hc32_ll_driver\inc;..\libraries\hc32f4a0_ddl\midwares\hc32\usb\usb_device_lib\device_class\single_cdc;..\libraries\hc32_drivers;..\..\..\components\net\at\include;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\libraries\hc32f4a0_ddl\drivers\cmsis\Device\HDSC\hc32f4xx\Include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\libc\posix\ipc;applications;..\..\..\libcpu\arm\common;board\config;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\drivers\include;..\libraries\hc32f4a0_ddl\midwares\hc32\usb\usb_device_lib\device_core;..\..\..\components\drivers\include;board\ports;board;..\..\..\components\libc\posix\io\eventfd;..\libraries\hc32f4a0_ddl\drivers\bsp\components\tca9539;..\..\..\libcpu\arm\cortex-m4;..\libraries\hc32f4a0_ddl\midwares\hc32\usb;..\..\..\components\utilities\ulog;..\libraries\hc32f4a0_ddl\drivers\bsp\ev_hc32f4a0_lqfp176
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: usb_dev_user.c usb_bsp.c usb_cdc.c atcmd.c usb_dev_desc.c cdc_data_process.c button.c led.c main.c
  group AT
    ../../../components/net/at/src/: at_client.c at_utils.c at_server.c at_cli.c at_base_cmd.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    board/: board.c board_config.c
    ../libraries/hc32f4a0_ddl/drivers/cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f4a0.s
    ../libraries/hc32_drivers/: drv_gpio.c drv_irq.c drv_soft_i2c.c drv_spi.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/hc32f4a0_ddl/drivers/hc32_ll_driver/src/: hc32_ll_clk.c hc32_ll_utility.c hc32_ll_efm.c hc32_ll_usb.c hc32f4a0_ll_interrupts_share.c hc32_ll_rmu.c hc32_ll_i2c.c hc32_ll_fcg.c hc32_ll_pwc.c hc32_ll_gpio.c hc32_ll_usart.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_aos.c hc32_ll_tmr0.c hc32_ll_keyscan.c hc32_ll_dma.c hc32_ll_sram.c hc32_ll_spi.c hc32_ll.c hc32_ll_fcm.c
    ../libraries/hc32f4a0_ddl/midwares/hc32/usb/usb_device_lib/device_class/single_cdc/: usb_dev_cdc_class.c
    ../libraries/hc32f4a0_ddl/midwares/hc32/usb/usb_device_lib/device_core/: usb_dev_core.c usb_dev_stdreq.c usb_dev_ctrleptrans.c usb_dev_int.c usb_dev_driver.c
    ../libraries/hc32f4a0_ddl/drivers/bsp/ev_hc32f4a0_lqfp176/: ev_hc32f4a0_lqfp176.c
    ../libraries/hc32f4a0_ddl/drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f4a0.c
  group rt_usbd
    ../../../components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    ../../../components/drivers/usb/usbdevice/class/: cdc_vcom.c
  group Utilities
    ../../../components/utilities/ulog/: ulog.c
    ../../../components/utilities/ulog/backend/: console_be.c
